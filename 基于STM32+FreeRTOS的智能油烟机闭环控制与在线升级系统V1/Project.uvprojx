# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0xC000) IROM(0x08008000,0x37000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: fromelf.exe --bin --output .\Objects\Project.bin .\Objects\Project.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Start;.\User;.\Library;.\Application;.\Bootloader;.\BSP;.\Common;.\Driver;.\Service;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM3;.\FreeRTOS\portable;.\FreeRTOS
  memory RVCT4: ROM 0x8008000 size 0x37000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group Application
    ./Application/: app_main.c sensor_task.c power_task.c task_key.c control_task.c task_motor.c task_speed.c task_auto.c task_anti_backflow.c task_ui.c task_log.c task_ota.c task_ota.h
  group Service
    ./Service/: sensor_service.c event_service.c control_service.c speed_service.c auto_control_service.c anti_backflow_service.c motor_control_service.c pid_service.c ui_service.c log_service.c
  group Driver
    ./Driver/: drv_console.c drv_sensor.c drv_actuator.c drv_key.c drv_motor_pwm.c drv_encoder.c drv_lcd.c
  group BSP
    ./BSP/: bsp_adc.c bsp_delay.c bsp_gpio.c bsp_spi.c bsp_tim.c bsp_usart.c bsp_power.c bsp_sys.c
  group Common
    ./Common/: message_def.h system_state.h board_pins.h ota_config.h ota_protocol.c ota_protocol.h ota_boot_control.c ota_boot_control.h
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
    ./FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group Start
    ./Start/: startup_stm32f10x_hd.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
