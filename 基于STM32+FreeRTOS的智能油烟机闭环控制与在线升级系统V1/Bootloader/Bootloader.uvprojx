# Keil uVision project Bootloader.uvprojx, settings and files
target Bootloader (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Bootloader +hex
  AfterMake: fromelf.exe --bin --output .\Objects\Bootloader.bin .\Objects\Bootloader.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,VECT_TAB_OFFSET=0
  c include: .;..\Start;..\User;..\Library;..\Common;..\BSP
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: .\Bootloader.sct
  group Bootloader
    ./: boot_main.c boot_sha256.c boot_p256.c boot_crypto.c boot_flash.c boot_metadata.c
  group Common
    ../Common/: ota_protocol.c ota_boot_control.c ota_config.h ota_public_key.h
  group Start
    ../Start/: startup_stm32f10x_hd.s system_stm32f10x.c core_cm3.c
  group STM32 Library
    ../Library/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_pwr.c stm32f10x_bkp.c
